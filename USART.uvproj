# Keil uVision project USART.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: USART +hex
  group User
    ./Source/User/: main.c
    ./Source/INC/: FreeRTOSConfig.h
  group Driver
    ./Source/Driver/src/: BSP_STC32G_GPIO.c BSP_STC32G_system.c BSP_STC32G_UART.c BSP_STC32G_NVIC.c BSP_STC32G_TIMER.c
  group ISR
    ./Source/Driver/isr/: BSP_STC32G_UART_ISR.c BSP_STC32G_TIMER_ISR.c
  group APP
    ./Source/APP/src/: app_uart.c app_cli.c
  group LIB
    ./Source/LIB/src/: crc.c gpio_digital.c
  group FreeRTOS
    ./Source/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group port
    ./Source/FreeRTOS/portable/STC32G12K128/: port.c
    ./Source/FreeRTOS/portable/MemMang/: heap_1.c
    $TC_ROOT$/../../../01_软件开发类/01_SDK&Doc/STC32G/FreeRTOS/FreeRTOS_STC32G_USART/Source/FreeRTOS/portable/STC32G12K128/: portasm.h portmacro.h
